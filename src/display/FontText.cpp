#include "display/FontText.h"

#include <stdint.h>

namespace {

struct Glyph {
    uint16_t codepoint;
    uint8_t  glyph;
};

// Non-ASCII characters in the CP437 font; keep in step with CP437_GLYPHS in ui/src/lib/render.ts
const Glyph GLYPHS[] = {
    {0x00A1, 0xAD}, {0x00A2, 0x9B}, {0x00A3, 0x9C}, {0x00A5, 0x9D}, {0x00AA, 0xA6},
    {0x00AB, 0xAE}, {0x00AC, 0xAA}, {0x00B0, 0xF8}, {0x00B1, 0xF1}, {0x00B2, 0xFD},
    {0x00B5, 0xE6}, {0x00B7, 0xFA}, {0x00BA, 0xA7}, {0x00BB, 0xAF}, {0x00BC, 0xAC},
    {0x00BD, 0xAB}, {0x00BF, 0xA8}, {0x00C4, 0x8E}, {0x00C5, 0x8F}, {0x00C6, 0x92},
    {0x00C7, 0x80}, {0x00C9, 0x90}, {0x00D1, 0xA5}, {0x00D6, 0x99}, {0x00DC, 0x9A},
    {0x00DF, 0xE1}, {0x00E0, 0x85}, {0x00E1, 0xA0}, {0x00E2, 0x83}, {0x00E4, 0x84},
    {0x00E5, 0x86}, {0x00E6, 0x91}, {0x00E7, 0x87}, {0x00E8, 0x8A}, {0x00E9, 0x82},
    {0x00EA, 0x88}, {0x00EB, 0x89}, {0x00EC, 0x8D}, {0x00ED, 0xA1}, {0x00EE, 0x8C},
    {0x00EF, 0x8B}, {0x00F1, 0xA4}, {0x00F2, 0x95}, {0x00F3, 0xA2}, {0x00F4, 0x93},
    {0x00F6, 0x94}, {0x00F7, 0xF6}, {0x00F9, 0x97}, {0x00FA, 0xA3}, {0x00FB, 0x96},
    {0x00FC, 0x81}, {0x00FF, 0x98}, {0x2022, 0x07}, {0x2190, 0x1B}, {0x2191, 0x18},
    {0x2192, 0x1A}, {0x2193, 0x19}, {0x2248, 0xF7}, {0x2264, 0xF3}, {0x2265, 0xF2},
    {0x2588, 0xDB}, {0x2591, 0xB0}, {0x2592, 0xB1}, {0x2593, 0xB2}, {0x25B2, 0x1E},
    {0x25BA, 0x10}, {0x25BC, 0x1F}, {0x25C4, 0x11}, {0x263A, 0x01}, {0x2665, 0x03},
};

char glyphFor(uint32_t codepoint) {
    for (const Glyph& g : GLYPHS) {
        if (g.codepoint == codepoint) return (char)g.glyph;
    }
    return '?';
}

}  // namespace

std::string toFontText(const char* utf8) {
    std::string out;
    if (!utf8) return out;

    const uint8_t* p = (const uint8_t*)utf8;
    while (*p) {
        uint8_t lead = *p;
        if (lead < 0x80) {
            out += (char)lead;
            p++;
            continue;
        }

        int extra = lead >= 0xF0 ? 3 : lead >= 0xE0 ? 2 : lead >= 0xC0 ? 1 : -1;
        uint32_t codepoint = extra == 3 ? lead & 0x07 : extra == 2 ? lead & 0x0F : lead & 0x1F;
        p++;
        // A stray continuation byte, or a sequence cut short, is one unknown character
        bool valid = extra > 0;
        for (int i = 0; valid && i < extra; i++) {
            if ((*p & 0xC0) != 0x80) {
                valid = false;
            } else {
                codepoint = (codepoint << 6) | (*p & 0x3F);
                p++;
            }
        }
        out += valid ? glyphFor(codepoint) : '?';
    }
    return out;
}
